# Repository FrizzyElectronics/MatrixLed8x8

File README.md:

# MatrixLed8x8
This module is an 8x8 LED matrix controlled via I2C with the help of the ht16k33 chip. It works flawlessly with the I2C port on the [Grape Board](https://github.com/FrizzyElectronics/Grape) adding color and animation to your projects.

## KiCad design MatrixLed.kicad_pcb

Parts:
C1: 10uF; C_1206
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64: LED_ALT; LED_0603
D65: 1N4148; D_SOD-123
JP1, JP2, JP3: Jumper_NO_Small; R_0805
P1: CONN_01X04; JST_PH_S4B-PH-SM4-TB_04x2.00mm_Angled
R1, R2, R3, R4, R5: 10K; R_0805
U1: HT16K33; SOIC-28W_7.5x17.9mm_Pitch1.27mm

Connections:
DIG0: D1.1 (K), D9.1 (K), D17.1 (K), D25.1 (K), D33.1 (K), D41.1 (K), D49.1 (K), D57.1 (K), D65.2 (A), U1.2 (COM0/AD)
DIG1: D2.1 (K), D10.1 (K), D18.1 (K), D26.1 (K), D34.1 (K), D42.1 (K), D50.1 (K), D58.1 (K), U1.3 (COM1)
DIG2: D3.1 (K), D11.1 (K), D19.1 (K), D27.1 (K), D35.1 (K), D43.1 (K), D51.1 (K), D59.1 (K), U1.4 (COM2)
DIG3: D4.1 (K), D12.1 (K), D20.1 (K), D28.1 (K), D36.1 (K), D44.1 (K), D52.1 (K), D60.1 (K), U1.5 (COM3)
DIG4: D5.1 (K), D13.1 (K), D21.1 (K), D29.1 (K), D37.1 (K), D45.1 (K), D53.1 (K), D61.1 (K), U1.6 (COM4)
DIG5: D6.1 (K), D14.1 (K), D22.1 (K), D30.1 (K), D38.1 (K), D46.1 (K), D54.1 (K), D62.1 (K), U1.7 (COM5)
DIG6: D7.1 (K), D15.1 (K), D23.1 (K), D31.1 (K), D39.1 (K), D47.1 (K), D55.1 (K), D63.1 (K), U1.8 (COM6)
DIG7: D8.1 (K), D16.1 (K), D24.1 (K), D32.1 (K), D40.1 (K), D48.1 (K), D56.1 (K), D64.1 (K), U1.9 (COM7)
GND: C1.2, P1.1, U1.1 (GND)
unnamed: D65.1 (K), R2.2, R3.2, R4.2
unnamed: JP1.2, R2.1
unnamed: JP2.2, R3.1
unnamed: JP3.2, R4.1
SCL: P1.3, R5.2, U1.26 (SCL)
SDA: P1.4, R1.2, U1.27 (SDA)
SEGA: D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), JP3.1, U1.25 (ROW0/A2)
SEGB: D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), JP2.1, U1.24 (ROW1/A1)
SEGC: D25.2 (A), D26.2 (A), D27.2 (A), D28.2 (A), D29.2 (A), D30.2 (A), D31.2 (A), D32.2 (A), JP1.1, U1.23 (ROW2/A0)
SEGD: D33.2 (A), D34.2 (A), D35.2 (A), D36.2 (A), D37.2 (A), D38.2 (A), D39.2 (A), D40.2 (A), U1.22 (ROW3)
SEGDP: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), U1.18 (ROW7)
SEGE: D41.2 (A), D42.2 (A), D43.2 (A), D44.2 (A), D45.2 (A), D46.2 (A), D47.2 (A), D48.2 (A), U1.21 (ROW4)
SEGF: D49.2 (A), D50.2 (A), D51.2 (A), D52.2 (A), D53.2 (A), D54.2 (A), D55.2 (A), D56.2 (A), U1.20 (ROW5)
SEGG: D57.2 (A), D58.2 (A), D59.2 (A), D60.2 (A), D61.2 (A), D62.2 (A), D63.2 (A), D64.2 (A), U1.19 (ROW6)
VCC: C1.1, P1.2, R1.1, R5.1, U1.28 (Vcc)

Board: 2 copper layers, 58.3 x 30.4 mm, 76 parts (9 on the bottom side), 24 nets.

## Commit log

2017-04-17 License Added
2017-04-17 Comenzando el esquematico
2017-04-17 Matriz terminada
2017-04-17 Logos
    Small and big logos for the board
2017-04-17 Max7219 añadido
2017-04-17 MAX7219 conectado con la matriz
2017-04-17 Power flags añadidos
2017-04-17 Campos del esquematico completados
2017-04-17 Leds girados para cambiar el MAX7219 por el HT16K33
2017-04-17 Esquema terminado con el HT16K33, anotaciones hechas
2017-04-17 DRC pasado y conector I2C añadido
2017-04-17 CvPCB terminado
2017-04-17 Añadida serigrafia reflectante
2017-04-24 Componentes colocados
2017-04-24 Placa enrutada, taladros realizados y componentes 3D añadidos
2017-04-24 Number changed
    Number of the atom changed to 64 representing the number of LEDs on the
    matrix.
2017-04-24 Serigrafia añadida
2017-04-24 DRC pasado y errores solucionados
2017-05-02 Guía de montaje / Assembly guides
    Añadida las guías de montaje / Assembly guides added
2018-03-04 arbol de carpetas cambiado
2018-03-11 Updated module description
